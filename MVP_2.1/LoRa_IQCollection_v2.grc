options:
  parameters:
    generate_options: qt_gui
    id: OFDM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: Band width (BW)
    label0: Both channels
    label1: Single channel
    num_opts: '2'
    option0: 1000e3
    option1: 125e3
    orient: Qt.QHBoxLayout
    type: real
    value: 125e3
    widget: radio_buttons
  states: {}
- name: BW_Label
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,2,1,1
    label: Bandwidth
    type: real
    value: 2*BW
  states: {}
- name: Fc
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Center Frequency (Fc)
    label0: Downlink
    label1: Uplink
    label2: Downlink and Uplink
    num_opts: '3'
    option0: 904.5e6
    option1: 904.3e6
    option2: 904.4e6
    orient: Qt.QHBoxLayout
    type: real
    value: 904.5e6
    widget: radio_buttons
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 2*BW
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: Fc
    freq_span: 2*BW
    gui_hint: 1,1,2,2
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      902-928 MHz ISM Band (Used in North America and other regions):
      In the US915 frequency plan, which is common in North America, channel 11 has a center frequency of 904.5 MHz.

      [LoRa Gateway]
      	CHANNEL_DOWNLINK 11
      	Fc =  904.5 MHz
      	BW = 125 KHz
      	Fs = 250, 000 S/Sec

      [LoRa End-device]
      	CHANNEL_UPLINK   10
      	Fc =   904.3 MHz
      	BW = 125 KHz
      	Fs = 250, 000 S/Sec
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    axislabels: 'False'
    bw: 2*BW
    color1: '"red"'
    ctrlpanel: 'True'
    fc: Fc
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,1
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: BW
    fc: Fc
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: BW
    center_freq0: Fc
    dev_addr: ''
    gain0: '20'
    samp_rate: 2*BW
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_throttle2_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
